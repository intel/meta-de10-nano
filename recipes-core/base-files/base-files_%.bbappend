FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

dirs755 += " /media/FAT"

PRINC = "3"

