RDEPENDS_${PN}_remove = "fbset"
