# Override build config

EXTRA_OECONF_de0-nano = "--program-prefix= --program-suffix= --with-x --without-perl --disable-openmp --without-xml --disable-opencl"
EXTRA_OECONF_de10-nano = "--program-prefix= --program-suffix= --with-x --without-perl --disable-openmp --without-xml --disable-opencl"
