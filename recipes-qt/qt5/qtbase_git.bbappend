PACKAGECONFIG_prepend_de10-nano = " linuxfb freetype fontconfig "
PACKAGECONFIG_MULTIMEDIA_de10-nano = ""

