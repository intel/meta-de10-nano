RRECOMMENDS_${PN}_remove = "pm-utils"
