RDEPENDS_remove = "libnss-mdns"
RDEPENDS_${PN}_remove = "libnss-mdns"
RRECOMMENDS_avahi-daemon_remove = "libnss-mdns"                     
RRECOMMENDS_${PN}_remove = "libnss-mdns"  
