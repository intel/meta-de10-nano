PACKAGECONFIG = "expat gnutls webdav zlib"
