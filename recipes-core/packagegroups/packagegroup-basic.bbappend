RRECOMMENDS_${PN}_remove = "cpufrequtils"
