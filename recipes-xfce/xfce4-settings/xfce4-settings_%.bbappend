PACKAGECONFIG_remove = "sound-setter"
RRECOMMENDS_${PN}_remove = "libcanberra-alsa"
RRECOMMENDS_${PN}_remove = "libcanberra-pulse"
